# Keil uVision project BDSGPS.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: BDSGPS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\core;..\modules\inc;..\system\inc
  group core
    ../core/: main.c
  group modules
    ../modules/src/: gps.c lcd12864.c
  group system
    ../system/src/: delay.c uart.c
